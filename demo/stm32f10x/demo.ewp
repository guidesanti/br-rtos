# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; ..\..\config; ..\..\device\bus\spi; ..\..\kernel; ..\..\kernel\inc; ..\..\kernel\src; ..\..\port\arch\Cortex-M3\IAR; ..\..\port\bsp; ..\..\port\bsp\stm32f10x; ..\..\port\bsp\stm32f10x\drivers; ..\..\port\bsp\stm32f10x\libs\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.srec
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: C:\Users\Guilherme\Workspace\BR-RTOS (trunk)\demo\stm32f10x\demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ./: demo.c system_stm32f10x.c
  group BR-RTOS/device/bus/spi
    ../../device/bus/spi/: spi_core.c
  group BR-RTOS/kernel
    ../../kernel/src/: device.c heap.c init.c ipc.c list.c object.c task.c timer.c
  group BR-RTOS/port/arch
    ../../port/arch/Cortex-M3/IAR/: iar_port.c iar_port_asm.s port.h
  group BR-RTOS/port/bsp
    ../../port/bsp/stm32f10x/: board.c startup.c stm32f10x_it.c
  group BR-RTOS/port/bsp/drivers
    ../../port/bsp/stm32f10x/drivers/: rtc.c spi.c usart.c
  group BR-RTOS/port/bsp/libs
    ../../port/bsp/stm32f10x/libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group config
    ./: demo.icf
