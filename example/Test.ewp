# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ; ..\config; ..\kernel; ..\kernel\inc; ..\kernel\src; ..\kernel\port\Cortex-M3\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: example.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../kernel/src/: heap.c task.c
    ../kernel/port/Cortex-M3/IAR/: iar_port.c iar_port_asm.s
    ./: main.c stm32f10x_it.c system_stm32f10x.c
